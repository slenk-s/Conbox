# Keil uVision project T1.uvprojx, settings and files
target T1 (5060960::V5.06 update 7 (build 960)::.\5.06_SLENK)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.19
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: T1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F003x8,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ../Core/INC;../Drivers/CMSIS/Include;../Drivers/PY32F003_HAL_Driver/Inc;../Drivers/CMSIS/Device/PY32F003/Include;..\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/PY32F003_HAL_Driver
    ../Drivers/PY32F003_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_pwr.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_exti.c py32f0xx_hal_usart.c py32f0xx_hal_uart.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_ll_utils.c py32f0xx_ll_rcc.c py32f0xx_ll_dma.c py32f0xx_ll_pwr.c py32f0xx_ll_gpio.c py32f0xx_ll_exti.c
  group Application/User/Core
    ../Core/SRC/: barcode_rx.c host_protocol.c barcode_app.c barcode_port.c barcode_view.c main.c gpio.c tim.c usart.c rcc.c py32f003_it.c py32f003_hal_msp.c
  group Application/MDK-ARM
    ./: startup_py32f003xx.s
  group Drivers/CMSIS
    ../Core/SRC/: system_py32f003.c
  group bsp
    ../OLED/: oled.c
